# Keil uVision project blink_stm32f103c8.uvprojx, settings and files
target Blink_QXK (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: f103c8_qxk +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: QXK_PRJ, NDEBUG
  c include: .\User\inc;.\Drivers;.\Cmsis;.\Qpc\platform\inc;.\Qpc\port\qxk\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry Reset_Handler
  group Generated
    ./User/src/: blink.c
    ./User/inc/: blink.h
  group user\src
    ./User/src/: main.c bsp.c
  group drivers
    ./Drivers/: startup_stm32f10x_md.s
  group platform
    ./QPC/platform/src/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
    ./Qpc/platform/src/: qk.c
  group port
    ./QPC/port/qxk/src/: qxk_port.c
    ./Qpc/port/qk/src/: qk_port.c
  group qspy
    ./QPC/spy/src/: qs.c qs_64bit.c qs_fp.c qs_rx.c qstamp.c
target Blink_QXK_QSpy (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: f103c8_qxk_qspy +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: Q_SPY,QXK_PRJ,DEBUG
  c include: .\User\inc;.\Drivers;.\Cmsis;.\Qpc\platform\inc;.\Qpc\port\qxk\inc;.\Qpc\spy\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry Reset_Handler
target Blink_QK (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: f103c8_qk +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: QK_PRJ, NDEBUG
  c include: .\User\inc;.\Drivers;.\Cmsis;.\Qpc\platform\inc;.\Qpc\port\qk\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry Reset_Handler
target Blink_QK_QSpy (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: f103c8_qk_qspy +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: Q_SPY,QK_PRJ, DEBUG
  c include: .\User\inc;.\Drivers;.\Cmsis;.\Qpc\platform\inc;.\Qpc\port\qk\inc;.\Qpc\spy\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry Reset_Handler
target Blink_QV (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: blink_stm32f103c8 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: QV_PRJ, NDEBUG
  c include: .\User\inc;.\Drivers;.\CMSIS;.\QPC\platform\inc;.\QPC\port\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry Reset_Handler
target Blink_QV_QSpy (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: blink_stm32f103c8 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: Q_SPY
  c include: .\User\inc;.\Drivers;.\CMSIS;.\QPC\platform\inc;.\QPC\port\inc;.\QPC\spy\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry Reset_Handler
